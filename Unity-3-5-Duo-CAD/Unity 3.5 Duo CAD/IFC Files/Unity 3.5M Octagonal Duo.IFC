Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Unity 3.5M Octagonal Duo.IFC
Time: 2020-06-19T02:31:37
Written by: SwIFC
Made in: SolidWorks 2017

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m
